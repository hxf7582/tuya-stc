# Keil uVision project 智能温湿度计.uvproj, settings and files
target 智能温湿度计 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 智能温湿度计 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\;.\src;.\mcu_sdk
  group user
    ./src/: main.c User_I2C.c User_Key.c User_OLED.c User_SHT30.c User_Timer.c codetab.c Uart_1.c Uart_2.c delay.c
  group mcu_sdk
    ./mcu_sdk/: mcu_api.c protocol.c system.c
